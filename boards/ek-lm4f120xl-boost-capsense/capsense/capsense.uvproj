# Keil uVision project capsense.uvproj, settings and files
target capsense (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: capsense
  AfterMake: fromelf --bin --output .\rvmdk\capsense.bin .\rvmdk\capsense.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR TARGET_IS_BLIZZARD_RA1
  c include: ..;..\..\..;..\..\ek-lm4f120xl;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: capsense.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: CTS_HAL.c CTS_Layer.c CTS_structure.c
    ../../ek-lm4f120xl/drivers/: buttons.c rgb.c
    ./: capsense.c startup_rvmdk.S
    ../../../utils/: uartstdio.c
  group Libraries
    ../../../driverlib/rvmdk-cm4f/: driverlib-cm4f.lib
  group Documentation
    ./: readme.txt
