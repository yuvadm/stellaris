# IAR project usb_dev_bulk.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  ICCARM.CCDefines: ewarm; PART_LM4F120H5QR; TARGET_IS_BLIZZARD_RA1; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..
  OBJCOPY.OOCOutputFile: usb_dev_bulk.bin
  ILINK.IlinkOutputFile: usb_dev_bulk.out
  ILINK.IlinkIcfFile: usb_dev_bulk.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm4f/Exe/: driverlib-cm4f.a
    ../../../usblib/ewarm-cm4f/Exe/: usblib-cm4f.a
  group Source
    ./: startup_ewarm.c usb_bulk_structs.c usb_dev_bulk.c
    ../../../utils/: uartstdio.c ustdlib.c
