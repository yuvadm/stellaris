# IAR project interrupts.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  ICCARM.CCDefines: ewarm; PART_LM4F120H5QR; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..
  OBJCOPY.OOCOutputFile: interrupts.bin
  ILINK.IlinkOutputFile: interrupts.out
  ILINK.IlinkIcfFile: interrupts.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm4f/Exe/: driverlib-cm4f.a
  group Source
    ./: interrupts.c startup_ewarm.c
    ../../../utils/: uartstdio.c
