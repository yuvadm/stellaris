# IAR project qs-rgb.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  ICCARM.CCDefines: ewarm; PART_LM4F120H5QR; TARGET_IS_BLIZZARD_RA2; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..
  OBJCOPY.OOCOutputFile: qs-rgb.bin
  ILINK.IlinkOutputFile: qs-rgb.out
  ILINK.IlinkIcfFile: qs-rgb.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../driverlib/ewarm-cm4f/Exe/: driverlib-cm4f.a
    ../../../usblib/ewarm-cm4f/Exe/: usblib-cm4f.a
  group Source
    ../drivers/: buttons.c rgb.c
    ../../../utils/: cmdline.c uartstdio.c ustdlib.c
    ./: qs-rgb.c rgb_commands.c startup_ewarm.c
