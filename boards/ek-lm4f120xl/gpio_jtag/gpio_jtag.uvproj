# Keil uVision project gpio_jtag.uvproj, settings and files
target gpio_jtag (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: gpio_jtag
  AfterMake: fromelf --bin --output .\rvmdk\gpio_jtag.bin .\rvmdk\gpio_jtag.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR TARGET_IS_BLIZZARD_RA1
  c include: ..;..\..\..;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: gpio_jtag.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: buttons.c
    ./: gpio_jtag.c startup_rvmdk.S
    ../../../utils/: uartstdio.c
  group Libraries
    ../../../driverlib/rvmdk-cm4f/: driverlib-cm4f.lib
  group Documentation
    ./: readme.txt
